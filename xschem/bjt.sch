** sch_path: xschem/bjt.sch
**.subckt bjt VE
*.opin VE
I1 VDD VE 10u
XQ1 GND GND VE sky130_fd_pr__pnp_05v5_W3p40L3p40 m=1
**.ends
.GLOBAL VDD
.GLOBAL GND
.end
